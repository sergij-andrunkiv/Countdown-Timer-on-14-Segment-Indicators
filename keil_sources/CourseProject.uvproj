# Keil uVision project CourseProject.uvproj, settings and files
target Target 1 (MCS-51)
  device: Core8051 Actel
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(12000000)
  output: CourseProject +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: CourseProject.asm
